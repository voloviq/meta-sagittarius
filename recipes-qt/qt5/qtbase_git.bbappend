PACKAGECONFIG:append = "xkbcommon"
