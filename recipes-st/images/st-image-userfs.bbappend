PACKAGE_INSTALL = " \
    libiio \
    ppp \
    usb-modeswitch \
    ppp-dialin \
    linux-examples-stm32mp1-userfs \
    "
