CORE_IMAGE_EXTRA_INSTALL += " \
	net-tools \
	openvpn \
	systemd-networkd-configuration \
	netplan \
	networkmanager \
	iproute2 \
	ppp \
	usb-modeswitch \
	usbip \
	ppp-dialin \
	libiio \
	packagegroup-st-demo \
	tslib \
    	tslib-calibrate \
    	tslib-conf \
    	tslib-dev \
    	tslib-tests \
"
